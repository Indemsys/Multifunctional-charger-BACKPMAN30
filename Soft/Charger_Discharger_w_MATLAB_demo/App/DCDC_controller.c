// ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
// 2022-03-31
// 16:41:05
// ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
#include   "App.h"


T_power_controller_state pwr_cbl;

static uint8_t   dac_inited;

uint32_t         dcdc_min_in_v;  // Кодированное в формате ADC значение минимального напряжения на входе зарядника для его нормальной работы


/*-----------------------------------------------------------------------------------------------------


  \param val
-----------------------------------------------------------------------------------------------------*/
void Set_DCDC_MODE(uint32_t val)
{
  Set_DCDC_MODE_pin(val);
  TIM1_set_CH3_mode(val);  // Переводим mode в pulse-skiping, если пин управлется через ШИМ
}


/*-----------------------------------------------------------------------------------------------------
   Аварийное выключение всех силовых цепей контроллера питания и зарядника

  \param void

  \return void DCDC_emergency
-----------------------------------------------------------------------------------------------------*/
void DCDC_emergency_shutdown(uint32_t fault)
{
  __disable_interrupts();
  Set_LSW_F(0);          // Отключаем нагрузку
  Set_DCDC_MODE(1);      // Переводим mode в pulse-skiping
  Set_EN_CHARGER(0);     // Отключаем зарядник
  Set_ASW_F(0);          // Разрываем ключ параллельный диоду от системы в аккумулятор
  Set_ASW_R(0);          // Разрываем ключ параллельный диоду от аккумулятора в систему
  Set_PSW_F(0);          // Разрываем ключ параллельный диоду от системы в источник питания
  Set_PSW_R(0);          // Разрываем ключ параллельный диоду от источника питания в систему
  pwr_cbl.fault = fault;
  pwr_cbl.control_state = 0;
  __enable_interrupts();
}

/*-----------------------------------------------------------------------------------------------------


  \param void
-----------------------------------------------------------------------------------------------------*/
void DCDC_reset_fault(void)
{
  pwr_cbl.fault = DCDC_NO_FAULT;
}


/*-----------------------------------------------------------------------------------------------------


  \param void
-----------------------------------------------------------------------------------------------------*/
void DCDC_toggle_state(void)
{
  if (pwr_cbl.fault != DCDC_NO_FAULT) return;

  switch (pwr_cbl.control_state)
  {
  case 0:
    // Зарядник выключен, нагрузка выключена

    if (Get_PSW_F() == 0)
    {
      // Если еще не подключен внешний источник питания, то подключить его
      Set_PSW_F(1); // Включаем прямой ключ
      Set_PSW_R(1); // Включаем реверсный ключ
      // Сделать паузу для завершения переходных процессов
      Wait_ms(100);
    }

    // Включаем зарядник
    Set_EN_CHARGER(1);

    pwr_cbl.control_state = 1;
    break;

  case 1:
    // Зарядник включен, нагрузка выключена
    Set_LSW_F(1); // Включаем нагрузку

    pwr_cbl.control_state = 2;
    break;

  case 2:
    // Зарядник включен, нагрузка включена
    Set_LSW_F(0); // Выключаем нагрузку

    pwr_cbl.control_state = 3;
    break;

  case 3:
    // Зарядник включен, нагрузка выключена
    Set_EN_CHARGER(0);     // Выключаем зарядник
    Set_DCDC_MODE(1);      // Переводим mode в pulse-skiping
    pwr_cbl.control_state = 0;
    break;

  }

}


/*-----------------------------------------------------------------------------------------------------


  \param void
-----------------------------------------------------------------------------------------------------*/
void DAC_proc(uint16_t data)
{
  if (dac_inited == 0)
  {
    dac_inited = 1;
    SPI_DAC_init();
    SPI_DAC_send(4, 0); // BUFF-GAIN = 1 Диапазон выходного напряжения от 0 до 2.5 В
  }

  SPI_DAC_send(8, data);

}

/*-----------------------------------------------------------------------------------------------------


  \param steps

  \return uint16_t
-----------------------------------------------------------------------------------------------------*/
uint16_t Get_DAC_value_from_steps(uint16_t steps)
{
  return 0xFFFF - (uint16_t)(roundf(((STEP_SET * steps)-0.06f) / STEP_V));
}

/*-----------------------------------------------------------------------------------------------------


  \param val

  \return float
-----------------------------------------------------------------------------------------------------*/
float Get_voltage_from_value(uint16_t val)
{
  return ((float)(0xFFFF - val)*STEP_V + MIN_VOIUT);
}

/*-----------------------------------------------------------------------------------------------------


  \param void

  \return uint16_t
-----------------------------------------------------------------------------------------------------*/
uint16_t Get_DAC_value(void)
{
  return pwr_cbl.dac_data;
}

/*-----------------------------------------------------------------------------------------------------


  \param void

  \return uint8_t
-----------------------------------------------------------------------------------------------------*/
uint8_t Get_DCDC_MODE(void)
{
  return pwr_cbl.dcdc_mode;
}

